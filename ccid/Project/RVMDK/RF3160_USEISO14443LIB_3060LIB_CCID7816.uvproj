# Keil uVision project RF3160_USEISO14443LIB_3060LIB_CCID7816.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TF-RF3160 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_adc.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_ld.s
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group main
    ../../src/main/: main.c stm32f10x_it.c DES_Fun.c managekey.c sms4.c mac.c Is8u256aDriver.c
    ../../src/umass/: lcd_show.c
  group CCID
    ../../src/ccid/: IFD.C ccid.c times.c
  group usb_hid
    ../../src/usb_hid/: hw_config.c usb_ccid.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group spi
    ../../src/spi/: spi.c
  group usart
    ../../src/usart/: usart.c
  group MAG_TTL
    ../../src/MAG_TTL/: magcard_drv.c magcardTTL.c
  group V_SAM
    ../../src/V_SAM/: V_SAM.c
  group umass
    ../../src/umass/: mass_mal.c scsi_data.c usb_bot.c usb_scsi.c usb_support.c cmd.c globle.c MainFile.c mem.c memory.c bluetooth.c SPI_SD_driver.c TS36EBG.c usb_Disk.c SPI1FlashDriver.c SPI_Flash.c LCD.c Display.c
  group ADC
    ../../src/ADC/: ad.c
  group THM3070
    ../../src/THM3070/: ISO14443.c thm3070.c
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: CashWay_RF +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL, IAPLOAD
  c include: ..\..\inc;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\src\usb_hid;..\..\src\sam_v;..\..\src\iso14443;..\..\src\thm3060;..\..\src\memory;..\..\src\Mifare;..\..\src\USE3060LIB;..\..\src\USE14443LIB;..\..\src\ccid;..\..\src\SC_DEV_LIB;..\..\src\USE7816LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
